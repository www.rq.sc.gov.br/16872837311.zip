Properties of the parts of a building model (IFC2X3)

# File
Description: Steel&Graphics IFC export
File name: COBERTURA_R01
Time: 2023-05-18T09:55:09-03:00
Author: TecnoMETAL 4D
Written by: ST-DEVELOPER v12
Comment: Generated by software containing ST-Developer * from STEP Tools, Inc. (www.steptools.com)
Comment: description
Comment: implementation_level
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorisation

# IfcProject, COBERTURA_R01
LongName: D:\MAGNUS ENGENHARIA.GRP\PMR PRAÇA.S&G\COBERTURA_R01.dwg

# IfcSite, Site
RefElevation: 0 mm

# IfcBuilding, COBERTURA_R01
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBeam: TUBO Ø 200X8.00 (172)
In: COBERTURA_R01
Type - PredefinedType: BEAM
Steel & Graphics Common - Grade: A36
Name | Description | Part Mark | Assembly Mark | Profile
32 x TUBO Ø 100X4.75 | Mark:T-1 Pos:T-1 Material:A36 | T-1 | T-1 | TUBO Ø 100X4.75
64 x TUBO Ø 100X4.75 | Mark:T-2 Pos:T-2 Material:A36 | T-2 | T-2 | TUBO Ø 100X4.75
2 x TUBO Ø 300X2.65 | Mark:VS-3 Pos:VS-3 Material:A36 | VS-3 | VS-3 | TUBO Ø 300X2.65
4 x TUBO Ø 300X2.65 | Mark:VS-1 Pos:VS-1 Material:A36 | VS-1 | VS-1 | TUBO Ø 300X2.65
TUBO Ø 100X4.75 | Mark:T-3 Pos:T-3 Material:A36 | T-3 | T-3 | TUBO Ø 100X4.75
TUBO Ø 100X4.75 | Mark:T-4 Pos:T-4 Material:A36 | T-4 | T-4 | TUBO Ø 100X4.75
2 x TUBO Ø 300X6.35 | Mark:VP-1 Pos:VP-1 Material:A36 | VP-1 | VP-1 | TUBO Ø 300X6.35
TUBO Ø 100X4.75 | Mark:T-5 Pos:T-5 Material:A36 | T-5 | T-5 | TUBO Ø 100X4.75
2 x TUBO Ø 300X2.65 | Mark:VS-2 Pos:VS-2 Material:A36 | VS-2 | VS-2 | TUBO Ø 300X2.65
8 x TUBO Ø 200X8.00 | Mark:MF-1 Pos:MF-1 Material:A36 | MF-1 | MF-1 | TUBO Ø 200X8.00
3 x TUBO Ø 300X2.65 | Mark:VT-1 Pos:VT-1 Material:A36 | VT-1 | VT-1 | TUBO Ø 300X2.65
2 x TUBO Ø 300X2.65 | Mark:VS-4 Pos:VS-4 Material:A36 | VS-4 | VS-4 | TUBO Ø 300X2.65
2 x TUBO Ø 300X6.35 | Mark:VP-2 Pos:VP-2 Material:A36 | VP-2 | VP-2 | TUBO Ø 300X6.35
48 x FERRO Ø3/4'' | Mark:INS-1 Pos:1 Material:A36 | 1 | INS-1 | FERRO Ø3/4''

# IfcColumn: TUBO Ø 300X12.70 (6)
In: COBERTURA_R01
Type - PredefinedType: COLUMN
Steel & Graphics Common - Grade: A36; Profile: TUBO Ø 300X12.70
Name | Description | Part Mark = Assembly Mark
TUBO Ø 300X12.70 | Mark:PM-2 Pos:PM-2 Material:A36 | PM-2
TUBO Ø 300X12.70 | Mark:PM-4 Pos:PM-4 Material:A36 | PM-4
TUBO Ø 300X12.70 | Mark:PM-3 Pos:PM-3 Material:A36 | PM-3
TUBO Ø 300X12.70 | Mark:PM-1 Pos:PM-1 Material:A36 | PM-1
TUBO Ø 300X12.70 | Mark:PM-5 Pos:PM-5 Material:A36 | PM-5
TUBO Ø 300X12.70 | Mark:PM-6 Pos:PM-6 Material:A36 | PM-6

# IfcPlate: PLATE 400x400x16 (6)
In: COBERTURA_R01
Type - PredefinedType: SHEET
Description: Mark:INS-1 Pos:2 Material:A36
Steel & Graphics Common - Part Mark: 2; Assembly Mark: INS-1; Grade: A36; Profile: PLATE 400x400x16

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: FERRO Ø3/4''
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 100X4.75
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 200X8.00
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 200X8.00
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 200X8.00
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 200X8.00
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 200X8.00
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 200X8.00
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 200X8.00
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 300X2.65
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 300X2.65
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 300X2.65
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 300X2.65
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 300X2.65
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 300X2.65
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 300X2.65
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 300X2.65
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 300X2.65
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 300X2.65
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 300X2.65
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 300X2.65
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 300X2.65
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 300X6.35
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 300X6.35
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 300X6.35
PredefinedType: BEAM

# IfcBeamType, no part of this type: TUBO Ø 300X6.35
PredefinedType: BEAM

# IfcColumnType, no part of this type: TUBO Ø 300X12.70
PredefinedType: COLUMN

# IfcColumnType, no part of this type: TUBO Ø 300X12.70
PredefinedType: COLUMN

# IfcColumnType, no part of this type: TUBO Ø 300X12.70
PredefinedType: COLUMN

# IfcColumnType, no part of this type: TUBO Ø 300X12.70
PredefinedType: COLUMN

# IfcColumnType, no part of this type: TUBO Ø 300X12.70
PredefinedType: COLUMN

# IfcPlateType, no part of this type: PLATE 400x400x16
PredefinedType: SHEET

# IfcPlateType, no part of this type: PLATE 400x400x16
PredefinedType: SHEET

# IfcPlateType, no part of this type: PLATE 400x400x16
PredefinedType: SHEET

# IfcPlateType, no part of this type: PLATE 400x400x16
PredefinedType: SHEET

# IfcPlateType, no part of this type: PLATE 400x400x16
PredefinedType: SHEET
