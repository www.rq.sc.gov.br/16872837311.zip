Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
Time: 2023-04-01T08:22:49
Made in: IfcPlusPlus

# IfcBuildingStorey, Nível 1
LongName: Nível 1; Elevation: 0 cm

# IfcFlowFitting: Alvenaria - piso (7)
In: Nível 1
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Requer aterramento: Sim; Comprimento: 40 cm; Largura: 40 cm; Profundidade: 40 cm; Indicação: 400x400x400; Posição: Piso
Identificação_Elemento - Aplicação: Caixa; Descrição: Caixa de passagem de embutir no piso; Nome: 400x400x400 mm; Classe: Caixa de passagem - embutir; Tipo: Alvenaria - piso; Rede: Lógica
Pset_JunctionBoxTypeCommon - Reference: Alvenaria - piso
AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - embutir - Alvenaria - 400x400x400mm: 1; Caixa de passagem - embutir - Alvenaria - Tampa 400x400x50mm: 1

# IfcFlowFitting: Aço pintada - média
In: Nível 1
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Requer aterramento: Sim; Comprimento: 30 cm; Largura: 12 cm; Profundidade: 30 cm; Indicação: 300x300x120; Posição: Média
Identificação_Elemento - Aplicação: Caixa; Descrição: Caixa de passagem de embutir na parede; Nome: 300x300x120 mm; Classe: Caixa de passagem - telefonia; Tipo: Aço pintada - média; Rede: Lógica
Pset_JunctionBoxTypeCommon - Reference: Aço pintada - média
AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - embutir - Aço pintada - ref Lukbox - 300x300x120 mm: 1

# IfcFlowFitting: Caixas de Passagem
In: Nível 1
AltoQi_Builder - Requer aterramento: Não; Comprimento: 40 cm; Largura: 40 cm; Profundidade: 40 cm; Indicação: Cx-40x40x40cm; Posição: Direta
Identificação_Elemento - Aplicação: Caixa; Descrição: Caixa de Passagem de Telecom Dim: 40x40x40cm; Nome: Caixa de Passagem PVC 40x40x40; Classe: Biblioteca BIM - Lógica; Tipo: Caixas de Passagem; Rede: Lógica
Pset_JunctionBoxTypeCommon - Reference: Caixas de Passagem
AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - embutir - PVC - 500x500x120mm: 1

# IfcFlowFitting: Quadro de Telecomunicação (3)
In: Nível 1
AltoQi_Builder - Requer aterramento: Não; Comprimento: 7.5 cm; Largura: 10 cm; Profundidade: 15 cm; Indicação: QT; Posição: Média
Identificação_Elemento - Aplicação: Caixa; Descrição: Quadro de Telecomunicação 22,5x33,2x12 cm; Nome: Quadro de Telecomunicação 22,5x33,2x12 cm; Classe: Biblioteca BIM - Lógica; Tipo: Quadro de Telecomunicação; Rede: Lógica
Pset_JunctionBoxTypeCommon - Reference: Quadro de Telecomunicação
AltoQi_QiBuilder-Itens_Associados - Quadro p/ telefonia - Caixa passagem p/ telefonia - Nº 3 - A=40, L=40, P=12 - cm: 1

# IfcFlowSegment: Eletroduto tipo pesado (PEAD) (27)
In: Nível 1
Type - PredefinedType: CONDUITSEGMENT
AltoQi_Builder - Comprimento máximo: 100 cm; Diâmetro interno: 5 cm; Diâmetro: ø2"; Espessura: 0.63 cm; Indicação: ø2"
Identificação_Elemento - Nome: 2"; Classe: Eletroduto PVC flexível; Tipo: Eletroduto tipo pesado (PEAD); Rede: Lógica; Aplicação: Circular
Pset_CableCarrierSegmentTypeCommon - Reference: Eletroduto tipo pesado (PEAD)
Pset_CableCarrierSegmentTypeCableLadderSegment - NominalLength: 100 cm
Name | Comprimento (cm) = Eletroduto PVC flexível - Eletroduto pesado - 2" (cm)
Lo1 | 1446.6
Lo10 | 780
Lo11 | 730
Lo12 | 550
Lo13 | 500
Lo14 | 290
Lo15 | 520
Lo16 | 1070
Lo17 | 1085
Lo18 | 925
Lo19 | 450
Lo2 | 346.6
Lo20 | 620
Lo21 | 800
Lo22 | 640
Lo23 | 710
Lo24 | 480
Lo25 | 260
Lo26 | 400
Lo27 | 1116.6
Lo3 | 1620
Lo4 | 1560
Lo5 | 400
Lo6 | 330
Lo7 | 500
Lo8 | 430
Lo9 | 430
