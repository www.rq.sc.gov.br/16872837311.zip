Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: IFC2X3
Time: 2023-04-19T22:31:15
Made in: IfcPlusPlus

# IfcBuildingStorey (2)
Name | LongName | Elevation (cm)
Nível 1 | Nível 1 | 0
Segundo Pavimento | Segundo Pavimento | 300

# IfcFlowController: Edifícios de uso coletivo - sobrepor, QM1
In: Nível 1
Type - PredefinedType: ENERGYMETER
AltoQi_Builder - Comprimento: 86.5 cm; Largura: 20 cm; Profundidade: 80 cm; Posição: Média; Esquema: 3F+N; Fases: R+S+T; Quadro Alimentador: AL1; Tensão: 380/220 V; DPS - Grupo: Dispositivo de proteção contra surto; DPS - Peça: 275 V - 80 KA; DPS - Quantidade: 4; Proteção - Grupo: Disjuntor tripolar termomagnético - DIN; Proteção - Peça: 63 A - 10 kA - C
Identificação_Elemento - Aplicação: Quadro de medição; Descrição: Quadro de medição sobrepor a 1,50m do piso; Nome: Quadro p/ 4 medidores; Classe: Quadro de medição - CELESC; Tipo: Edifícios de uso coletivo - sobrepor; Rede: Elétrica
Pset_FlowMeterTypeCommon - Reference: Edifícios de uso coletivo - sobrepor
Pset_ElectricalDeviceCommon-Ponto1 - NominalCurrent: 63 A; NumberOfPoles: 3; sets with these values: 2
AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Preto: 400 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 6 mm² - Verde: 100 cm; Dispositivo de Proteção - Disjuntor Tripolar Termomagnético - norma DIN - Curva C - 50 A - 10 kA: 1; Dispositivo de Proteção - Disjuntor Tripolar Termomagnético - norma DIN - Curva C - 63 A - 10 kA: 1; Dispositivo de Proteção - Disjuntor Unipolar Termomagnético - norma DIN - Curva C - 50 A - 10 kA: 3; Dispositivo de Proteção - Dispositivo de proteção contra surto - 275 V - 80 KA: 4; Quadro de medição - CELESC - Edifícios de uso coletivo - sobrepor - Quadro p/ 4 medidores: 1

# IfcFlowController: Entrada de serviço - Ramal de entrada subterrâneo, AL1
In: Nível 1
Type - PredefinedType: ENERGYMETER
AltoQi_Builder - Comprimento: 30 cm; Largura: 10 cm; Profundidade: 30 cm; Indicação: DES. Nº 16; Posição: Baixa; Esquema: 3F+N; Fases: R+S+T; Tensão: 380/220 V
Identificação_Elemento - Aplicação: Entrada de serviço; Descrição: Entrada de serviço subterrânea; Nome: Eletroduto 3" (TN32) - 4 fios - Trifásico (380V/220V); Classe: Entrada de Serviço - ENERGISA; Tipo: Entrada de serviço - Ramal de entrada subterrâneo; Rede: Elétrica
Pset_FlowMeterTypeCommon - Reference: Entrada de serviço - Ramal de entrada subterrâneo
Pset_ElectricalDeviceCommon-Ponto1 - NominalCurrent: 125 A; NumberOfPoles: 3
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Arruela zamak - 3": 3; Acessórios p/ eletrodutos - Bucha zamak - 3": 5; Acessórios p/ eletrodutos - Cabeçote p/ Entrada de Energia - 3/4": 1; Acessórios p/ eletrodutos - Curva 90º aço galvanizado - 3'': 1; Acessórios p/ eletrodutos - Fitas - Aço Inox: 4; Acessórios p/ eletrodutos - Luva aço galvan. leve - 2.1/2": 3; Acessórios p/ eletrodutos - Placa de identificação da unidade consumidora - ENERGISA: 1; Material p/ entrada serviço - Caixa de passagem concreto/alvenaria - CP01: 2; Material p/ entrada serviço - Isolador roldana - 76x79mm: 4; Material p/ entrada serviço - Poste concreto armado - Comprimento 7,5m: 1; Material p/ entrada serviço - Tubo aço galv. vara 6,0m - 3/4": 2

# IfcFlowFitting: Alvenaria - piso (23)
In: Nível 1
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Posição: Piso
Identificação_Elemento - Aplicação: Caixa de passagem de fiação; Classe: Caixa de passagem - embutir; Tipo: Alvenaria - piso; Rede: Elétrica
Pset_JunctionBoxTypeCommon - Reference: Alvenaria - piso
Name | Comprimento (cm) | Largura (cm) | Profundidade (cm) | Indicação | Descrição | Nome | Caixa de passagem - embutir - Alvenaria - 300x300x300mm = Caixa de passagem - embutir - Alvenaria - Tampa 300x300x50mm
CX1 | 30 | 30 | 30 | 300x300x300 | Caixa de passagem de embutir no piso | 300x300x300 mm | 1
CX10 | 30 | 30 | 30 | 300x300x300 | Caixa de passagem de embutir no piso | 300x300x300 mm | 1
CX11 | 30 | 30 | 30 | 300x300x300 | Caixa de passagem de embutir no piso | 300x300x300 mm | 1
CX12 | 30 | 30 | 30 | 300x300x300 | Caixa de passagem de embutir no piso | 300x300x300 mm | 1
CX13 | 30 | 30 | 30 | 300x300x300 | Caixa de passagem de embutir no piso | 300x300x300 mm | 1
CX14 | 30 | 30 | 30 | 300x300x300 | Caixa de passagem de embutir no piso | 300x300x300 mm | 1
CX15 | 30 | 30 | 30 | 300x300x300 | Caixa de passagem de embutir no piso | 300x300x300 mm | 1
CX16 | 30 | 30 | 30 | 300x300x300 | Caixa de passagem de embutir no piso | 300x300x300 mm | 1
CX17 | 30 | 30 | 30 | 300x300x300 | Caixa de passagem de embutir no piso | 300x300x300 mm | 1
CX18 | 30 | 30 | 30 | 300x300x300 | Caixa de passagem de embutir no piso | 300x300x300 mm | 1
CX19 | 30 | 30 | 30 | 300x300x300 | Caixa de passagem de embutir no piso | 300x300x300 mm | 1
CX2 | 30 | 30 | 30 | 300x300x300 | Caixa de passagem de embutir no piso | 300x300x300 mm | 1
CX21 | 71 | 95 | 90 | D400kN-700x460mm | Caixa de passagem subterrânea em alvenaria, Dim Int: 650x410x800 (LxCxP), com tampa de Ferro Fundido D400kN Dim: 700x460mm | 650x410x800mm Tampa D400kN Energia | AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - embutir - Alvenaria - Caixa de Passagem em Alvenaria Dim Ext: 950x710x900mm - LxCxP - -Dim Int: 650x410x800mm - LxCxP: 1; Caixa de passagem - embutir - Alvenaria - Tampa Ferro Fundido, D400kN, dim 700x460mm: 1
CX22 | 30 | 30 | 30 | 300x300x300 | Caixa de passagem de embutir no piso | 300x300x300 mm | 1
CX25 | 30 | 30 | 30 | 300x300x300 | Caixa de passagem de embutir no piso | 300x300x300 mm | 1
CX26 | 30 | 30 | 30 | 300x300x300 | Caixa de passagem de embutir no piso | 300x300x300 mm | 1
CX3 | 30 | 30 | 30 | 300x300x300 | Caixa de passagem de embutir no piso | 300x300x300 mm | 1
CX4 | 30 | 30 | 30 | 300x300x300 | Caixa de passagem de embutir no piso | 300x300x300 mm | 1
CX5 | 30 | 30 | 30 | 300x300x300 | Caixa de passagem de embutir no piso | 300x300x300 mm | 1
CX6 | 30 | 30 | 30 | 300x300x300 | Caixa de passagem de embutir no piso | 300x300x300 mm | 1
CX7 | 30 | 30 | 30 | 300x300x300 | Caixa de passagem de embutir no piso | 300x300x300 mm | 1
CX8 | 30 | 30 | 30 | 300x300x300 | Caixa de passagem de embutir no piso | 300x300x300 mm | 1
CX9 | 30 | 30 | 30 | 300x300x300 | Caixa de passagem de embutir no piso | 300x300x300 mm | 1

# IfcFlowFitting: Aço pintada - média (2)
In: Nível 1
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Comprimento: 23 cm; Largura: 10.2 cm; Profundidade: 23 cm; Indicação: 230x230x102; Posição: Média
Identificação_Elemento - Aplicação: Caixa de passagem de fiação; Descrição: Caixa de passagem de embutir na parede; Nome: 230x230x102 mm; Classe: Caixa de passagem - embutir; Tipo: Aço pintada - média; Rede: Elétrica
Pset_JunctionBoxTypeCommon - Reference: Aço pintada - média
AltoQi_QiBuilder-Itens_Associados - Caixa de passagem - embutir - Aço pintada - ref Cemar - 230x230x102 mm: 1
Name
CX23
CX24

# IfcFlowFitting: Barr. trif., - DIN (Ref. Hager) (4)
In: Nível 1
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Número de polos: 46; Padrão das proteções: DIN; Comprimento: 28.15 cm; Largura: 9.85 cm; Profundidade: 64.65 cm; Posição: Média; Quadro Alimentador: QM1; DPS - Grupo: Nenhum; DPS - Peça: Nenhuma; Proteção de Manutenção - Peça: 50 A - 10 kA - C; Proteção - Peça: 50 A - 10 kA - C
Identificação_Elemento - Aplicação: Quadro de distribuição; Descrição: Quadro de distribuição - sobrepor a 1,50m do piso; Nome: Cap. 46 disj. unip. - In Pente 100A; Classe: Quadro distrib. plástico - sobrepor; Tipo: Barr. trif., - DIN (Ref. Hager); Rede: Elétrica
Pset_JunctionBoxTypeCommon - Reference: Barr. trif., - DIN (Ref. Hager)
Pset_ElectricalDeviceCommon-Ponto1 - NominalCurrent: 50 A
AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Arruela de pressão galvan. - 1/4": 4; Acessórios uso geral - Bucha de nylon - S6: 4; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 4,8x45mm autoatarrachante: 4; Quadro distrib. plástico - sobrepor - Barr. trif., - DIN - Ref. Hager - Cap. 46 disj. unip. - In Pente 100A: 1
Name | Esquema | Fases | Tensão | DPS - Quantidade | Proteção de Manutenção - Grupo = Proteção - Grupo | NumberOfPoles | Dispositivo de Proteção - Disjuntor Unipolar Termomagnético - norma DIN - Curva C - 50 A - 10 kA
QD-BAR 01 | F+N | S | 220 V | 2 | Disjuntor unipolar termomagnético - DIN | 1 | 1
QD-BAR 02 | F+N | T | 220 V | 2 | Disjuntor unipolar termomagnético - DIN | 1 | 1
QD-BAR 03 | F+N | R | 220 V | 2 | Disjuntor unipolar termomagnético - DIN | 1 | 1
QD-PRAÇA | 3F+N | R+S+T | 380/220 V | 4 | Disjuntor tripolar termomagnético - DIN | 3 | AltoQi_QiBuilder-Itens_Associados - Dispositivo de Comando - Interruptor horário - 230V - Programação analógica diária - 24h: 5; Dispositivo de Proteção - Disjuntor Tripolar Termomagnético - norma DIN - Curva C - 50 A - 10 kA: 3; Dispositivo de Proteção - Disjuntor Unipolar Termomagnético - norma DIN - Curva C - 10 A - 10 kA: 9; Dispositivo de Proteção - Interruptor bipolar DR - fase/neutro - In 30mA - DIN - 25 A: 2; Dispositivo de Proteção - Interruptor tetrapolar DR - 3 fases/neutro - In 30mA - DIN - 25 A: 1; Dispositivo de Proteção - Interruptor tetrapolar DR - 3 fases/neutro - In 30mA - DIN - 63 A: 2

# IfcFlowFitting: Condulete 5 entradas (6)
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Indicação: 5e
Identificação_Elemento - Aplicação: Conexão; Descrição: Condulete de PVC 5 entradas; Classe: Biblioteca BIM - Elétrica aparente PVC; Tipo: Condulete 5 entradas; Rede: Elétrica
Pset_JunctionBoxTypeCommon - Reference: Condulete 5 entradas
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Condulete PVC 5 entradas - 1/2": 1; Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Dispositivo Elétrico - sobrepor - Tampa PVC p/ condulete - Tampa cega: 1
Name | In | Posição | Nome
5 x  | Nível 1 | Baixa | 1/2" - baixa
 | Segundo Pavimento | Teto | 1/2" - teto

# IfcFlowFitting: Condulete 5 entradas - Pontos de força - Uso geral (2)
In: Segundo Pavimento
AltoQi_Builder - Requer aterramento: Sim; Comprimento: 5 cm; Largura: 4.3 cm; Profundidade: 9.45 cm; Posição: Média
AltoQi_Builder-Ponto1 - Fator de potência (%): 90; Potência (W): 600; Quantidade: 1; Rendimento (%): 100; Tipo de ponto: Tomada 2P+T
Identificação_Elemento - Aplicação: Caixa; Descrição: Condulete PVC 5 entradas - Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,10m do piso; Nome: 2P+T 10 A - 600 W - média; Classe: Biblioteca BIM - Elétrica aparente PVC; Tipo: Condulete 5 entradas - Pontos de força - Uso geral; Rede: Elétrica
Circuito - Circuito_1: 10 - Tomadas Banheiros; Comando_1: Nenhum; Pavimento_do_circuito_1: Nível 1; Quadro_1: QD-PRAÇA
Pset_JunctionBoxTypeCommon - Reference: Condulete 5 entradas - Pontos de força - Uso geral
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Condulete PVC 5 entradas - Condulete PVC 5 entradas: 1; Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Dispositivo Elétrico - sobrepor - Tampa PVC p/ condulete - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1

# IfcFlowFitting: Condulete 6 entradas (8)
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Indicação: 6e; Posição: Teto
Identificação_Elemento - Aplicação: Conexão; Descrição: Condulete de PVC 6 entradas; Classe: Biblioteca BIM - Elétrica aparente PVC; Tipo: Condulete 6 entradas; Rede: Elétrica
Pset_JunctionBoxTypeCommon - Reference: Condulete 6 entradas
AltoQi_QiBuilder-Itens_Associados - Acessórios uso geral - Bucha de nylon - S4: 2; Acessórios uso geral - Parafuso fenda galvan. cab. panela - 2,9x25mm autoatarrachante: 2; Dispositivo Elétrico - sobrepor - Tampa PVC p/ condulete - Tampa cega: 1
Name | In | Nome
4 x  | Nível 1 | 1" - teto | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Condulete PVC 6 entradas - 1": 1
4 x  | Segundo Pavimento | 3/4" - teto | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Condulete PVC 6 entradas - 3/4": 1

# IfcFlowFitting: Haste de aterramento com caixa de inspeção (7)
In: Nível 1
Type - PredefinedType: USERDEFINED
AltoQi_Builder - Altura: 240 cm; Posição: Piso
Identificação_Elemento - Aplicação: Haste de aterramento; Descrição: Caixa de inspeção - Cimento - Ø300x300m c/ haste 3/4" x 2,40m; Nome: Cimento - Ø300x300mm c/ haste 3/4" x 2,40; Classe: Aterramento; Tipo: Haste de aterramento com caixa de inspeção; Rede: Elétrica
Pset_JunctionBoxTypeCommon - Reference: Haste de aterramento com caixa de inspeção
AltoQi_QiBuilder-Itens_Associados - Aterramento - Caixa de inspeção - Cimento - Ø300x300mm: 1; Aterramento - Haste de aterramento - cobreada - 3/4" x 2,40m: 1

# IfcFlowFitting: Pontos de comando (4)
In: Segundo Pavimento
AltoQi_Builder - Requer aterramento: Não; Comprimento: 15 cm; Largura: 15 cm; Profundidade: 11 cm; Posição: Teto
AltoQi_Builder-Ponto1 - Quantidade: 1; Tipo de ponto: Interruptor sensor de presença
Identificação_Elemento - Aplicação: Caixa; Descrição: Interruptor sensor de presença teto; Nome: Sensor de presença Teto (R00); Classe: Biblioteca BIM - Elétrica; Tipo: Pontos de comando; Rede: Elétrica
Circuito - Circuito_1: 9 - Iluminação Banheiros; Pavimento_do_circuito_1: Nível 1; Quadro_1: QD-PRAÇA
Pset_JunctionBoxTypeCommon - Reference: Pontos de comando
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa PVC octogonal - 4"x 4": 1; Dispositivo de Comando - Interruptor autom. por presença - Teto - 220V - 1200W - 360º: 1
Name | Comando_1
 | q
 | r
 | p
 | o

# IfcFlowFitting: Pontos de força - Uso específico (2)
In: Nível 1
AltoQi_Builder - Requer aterramento: Sim; Comprimento: 7 cm; Largura: 4.75 cm; Profundidade: 10.85 cm; Posição: Baixa
AltoQi_Builder-Ponto1 - Fator de potência (%): 82; Potência (W): 20000; Quantidade: 1; Rendimento (%): 89; Tipo de ponto: Tomada 3P+T
Identificação_Elemento - Aplicação: Caixa; Descrição: Ponto para sauna a 0,30m do piso; Nome: Ponto de Força - Sauna; Classe: Biblioteca BIM - Elétrica; Tipo: Pontos de força - Uso específico; Rede: Elétrica
Circuito - Comando_1: Nenhum; Pavimento_do_circuito_1: Nível 1; Quadro_1: QD-PRAÇA
Pset_JunctionBoxTypeCommon - Reference: Pontos de força - Uso específico
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1; Dispositivo Elétrico - embutido - Placa 2x4" - Placa c/ furo: 1
Name | Circuito_1
 | 8 - Tomada Trifásica (CX 02)
 | 7 - Tomada Trifásica (CX 01)

# IfcFlowFitting: Pontos de força - Uso geral (2)
In: Nível 1
AltoQi_Builder - Requer aterramento: Sim; Comprimento: 7 cm; Largura: 4.75 cm; Profundidade: 10.85 cm; Posição: Média
AltoQi_Builder-Ponto1 - Fator de potência (%): 90; Potência (W): 1000; Quantidade: 1; Rendimento (%): 100; Tipo de ponto: Tomada 2P+T
Identificação_Elemento - Aplicação: Caixa; Descrição: Tomada hexagonal (NBR 14136) - 2P+T 10 A a 1,10m do piso; Nome: 2P+T 10 A - 1000 W - média; Classe: Biblioteca BIM - Elétrica; Tipo: Pontos de força - Uso geral; Rede: Elétrica
Circuito - Comando_1: Nenhum; Pavimento_do_circuito_1: Nível 1; Quadro_1: QD-PRAÇA
Pset_JunctionBoxTypeCommon - Reference: Pontos de força - Uso geral
AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Caixa PVC - 4x2": 1; Dispositivo Elétrico - embutido - Placa 2x4" - Placa p/ 1 função: 1; Dispositivo Elétrico - embutido - S/ placa - Tomada hexagonal - NBR 14136 - 2P+T 10A: 1
Name | Circuito_1
 | 6 - Tomada Monofásica (CX 02)
 | 5 - Tomada Monofásica (CX 01)

# IfcFlowSegment: Eletroduto c/ braçadeira cunha (55)
Type - PredefinedType: CONDUITSEGMENT
AltoQi_Builder - Comprimento máximo: 300 cm
Identificação_Elemento - Classe: Eletroduto PVC encaixe; Tipo: Eletroduto c/ braçadeira cunha; Rede: Elétrica; Aplicação: Circular
Pset_CableCarrierSegmentTypeCommon - Reference: Eletroduto c/ braçadeira cunha
Pset_CableCarrierSegmentTypeCableLadderSegment - NominalLength: 300 cm
Name | In | Diâmetro interno (cm) | Diâmetro = Indicação | Espessura (cm) | Comprimento (cm) | Nome | Acessórios uso geral - Bucha de nylon - S6 = Acessórios uso geral - Parafuso fenda galvan. cab. panela - 4,2x32mm autoatarrachante | Eletroduto PVC encaixe - Braçadeira galvan. tipo cunha - 3/4" | Eletroduto PVC encaixe - Eletroduto, vara 3,0m - 3/4" (cm)
El118 | Nível 1 | 3.2 | ø1" | 0.21 | 278 | 1" | 3 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Amarelo: 278 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Azul claro: 278 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 278 cm; Eletroduto PVC encaixe - Braçadeira galvan. tipo cunha - 1": 3; Eletroduto PVC encaixe - Eletroduto, vara 3,0m - 1": 278 cm
El119 | Nível 1 | 3.2 | ø1" | 0.21 | 278 | 1" | 3 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Amarelo: 278 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Azul claro: 278 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 278 cm; Eletroduto PVC encaixe - Braçadeira galvan. tipo cunha - 1": 3; Eletroduto PVC encaixe - Eletroduto, vara 3,0m - 1": 278 cm
El120 | Nível 1 | 3.2 | ø1" | 0.21 | 620 | 1" | 7 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Amarelo: 620 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Azul claro: 620 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 620 cm; Eletroduto PVC encaixe - Braçadeira galvan. tipo cunha - 1": 7; Eletroduto PVC encaixe - Eletroduto, vara 3,0m - 1": 620 cm; Acessórios p/ eletrodutos - Luva PVC encaixe - 1": 2
El121 | Nível 1 | 3.2 | ø1" | 0.21 | 630 | 1" | 7 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Amarelo: 630 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Azul claro: 630 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 630 cm; Eletroduto PVC encaixe - Braçadeira galvan. tipo cunha - 1": 7; Eletroduto PVC encaixe - Eletroduto, vara 3,0m - 1": 630 cm; Acessórios p/ eletrodutos - Luva PVC encaixe - 1": 2
El123 | Nível 1 | 3.2 | ø1" | 0.21 | 660 | 1" | 7 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Amarelo: 660 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Azul claro: 660 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 660 cm; Eletroduto PVC encaixe - Braçadeira galvan. tipo cunha - 1": 7; Eletroduto PVC encaixe - Eletroduto, vara 3,0m - 1": 660 cm; Acessórios p/ eletrodutos - Luva PVC encaixe - 1": 2
El125 | Nível 1 | 2.5 | ø3/4" | 0.18 | 670 | 3/4" | 7 | 7 | 670 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Amarelo: 670 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Azul claro: 670 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 670 cm; Acessórios p/ eletrodutos - Luva PVC encaixe - 3/4": 2
El129 | Nível 1 | 3.2 | ø1" | 0.21 | 350 | 1" | 4 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Amarelo: 350 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Azul claro: 350 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 350 cm; Eletroduto PVC encaixe - Braçadeira galvan. tipo cunha - 1": 4; Eletroduto PVC encaixe - Eletroduto, vara 3,0m - 1": 350 cm; Acessórios p/ eletrodutos - Luva PVC encaixe - 1": 1
El134 | Nível 1 | 3.2 | ø1" | 0.21 | 20 | 1" | 1 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Azul claro: 20 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 20 cm; Eletroduto PVC encaixe - Braçadeira galvan. tipo cunha - 1": 1; Eletroduto PVC encaixe - Eletroduto, vara 3,0m - 1": 20 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Preto: 20 cm
El135 | Nível 1 | 3.2 | ø1" | 0.21 | 20 | 1" | 1 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Azul claro: 20 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 20 cm; Eletroduto PVC encaixe - Braçadeira galvan. tipo cunha - 1": 1; Eletroduto PVC encaixe - Eletroduto, vara 3,0m - 1": 20 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Preto: 20 cm
El136 | Nível 1 | 3.2 | ø1" | 0.21 | 270 | 1" | 3 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Amarelo: 270 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Azul claro: 270 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 270 cm; Eletroduto PVC encaixe - Braçadeira galvan. tipo cunha - 1": 3; Eletroduto PVC encaixe - Eletroduto, vara 3,0m - 1": 270 cm
El137 | Nível 1 | 3.2 | ø1" | 0.21 | 50 | 1" | 1 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Amarelo: 50 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Azul claro: 50 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 50 cm; Eletroduto PVC encaixe - Braçadeira galvan. tipo cunha - 1": 1; Eletroduto PVC encaixe - Eletroduto, vara 3,0m - 1": 50 cm
El151 | Nível 1 | 2.5 | ø3/4" | 0.18 | 170 | 3/4" | 2 | 2 | 170 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 170 cm
El152 | Nível 1 | 2.5 | ø3/4" | 0.18 | 280 | 3/4" | 3 | 3 | 280 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 280 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 280 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 280 cm
El153 | Nível 1 | 2.5 | ø3/4" | 0.18 | 220 | 3/4" | 3 | 3 | 220 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 220 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 220 cm
El154 | Nível 1 | 2.5 | ø3/4" | 0.18 | 230 | 3/4" | 3 | 3 | 230 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 230 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 230 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 230 cm
El156 | Nível 1 | 2.5 | ø3/4" | 0.18 | 170 | 3/4" | 2 | 2 | 170 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 170 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 170 cm
El157 | Nível 1 | 2.5 | ø3/4" | 0.18 | 160 | 3/4" | 2 | 2 | 160 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 160 cm
El158 | Nível 1 | 2.5 | ø3/4" | 0.18 | 190 | 3/4" | 2 | 2 | 190 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 190 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 190 cm
El159 | Nível 1 | 2.5 | ø3/4" | 0.18 | 220 | 3/4" | 3 | 3 | 220
El161 | Nível 1 | 2.5 | ø3/4" | 0.18 | 230 | 3/4" | 3 | 3 | 230
El162 | Nível 1 | 2.5 | ø3/4" | 0.18 | 220 | 3/4" | 3 | 3 | 220
El163 | Nível 1 | 2.5 | ø3/4" | 0.18 | 230 | 3/4" | 3 | 3 | 230
El164 | Nível 1 | 2.5 | ø3/4" | 0.18 | 160 | 3/4" | 2 | 2 | 160
El165 | Nível 1 | 2.5 | ø3/4" | 0.18 | 160 | 3/4" | 2 | 2 | 160 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 160 cm
El166 | Nível 1 | 2.5 | ø3/4" | 0.18 | 150 | 3/4" | 2 | 2 | 150
El167 | Nível 1 | 2.5 | ø3/4" | 0.18 | 150 | 3/4" | 2 | 2 | 150
El168 | Nível 1 | 2.5 | ø3/4" | 0.18 | 190 | 3/4" | 2 | 2 | 190
El169 | Nível 1 | 2.5 | ø3/4" | 0.18 | 230 | 3/4" | 3 | 3 | 230
El170 | Nível 1 | 2.5 | ø3/4" | 0.18 | 180 | 3/4" | 2 | 2 | 180
El175 | Nível 1 | 2.5 | ø3/4" | 0.18 | 30 | 3/4" | 1 | 1 | 30
El175 | Nível 1 | 2.5 | ø3/4" | 0.18 | 100 | 3/4" | 1 | 1 | 100
El176 | Nível 1 | 2.5 | ø3/4" | 0.18 | 360 | 3/4" | 4 | 4 | 360
El177 | Nível 1 | 2.5 | ø3/4" | 0.18 | 120 | 3/4" | 2 | 2 | 120
El178 | Nível 1 | 2.5 | ø3/4" | 0.18 | 210 | 3/4" | 3 | 3 | 210
El179 | Nível 1 | 2.5 | ø3/4" | 0.18 | 680 | 3/4" | 7 | 7 | 680 | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Luva PVC encaixe - 3/4": 1
El10 | Segundo Pavimento | 2.5 | ø3/4" | 0.18 | 20 | 3/4" | 1 | 1 | 20 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 20 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 20 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 20 cm
El10 | Segundo Pavimento | 2.5 | ø3/4" | 0.18 | 60 | 3/4" | 1 | 1 | 60 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 60 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 60 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 60 cm
El10 | Segundo Pavimento | 2.5 | ø3/4" | 0.18 | 110 | 3/4" | 2 | 2 | 110 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 110 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 110 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 110 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 110 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 110 cm
El11 | Segundo Pavimento | 2.5 | ø3/4" | 0.18 | 50 | 3/4" | 1 | 1 | 50 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 100 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 50 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 50 cm
El12 | Segundo Pavimento | 2.5 | ø3/4" | 0.18 | 210 | 3/4" | 3 | 3 | 210 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 210 cm
El13 | Segundo Pavimento | 2.5 | ø3/4" | 0.18 | 210 | 3/4" | 3 | 3 | 210 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 210 cm
El14 | Segundo Pavimento | 2.5 | ø3/4" | 0.18 | 60 | 3/4" | 1 | 1 | 60 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 120 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 60 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 60 cm
El14 | Segundo Pavimento | 2.5 | ø3/4" | 0.18 | 60 | 3/4" | 1 | 1 | 60 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 120 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 60 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 60 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 60 cm
El15 | Segundo Pavimento | 2.5 | ø3/4" | 0.18 | 110 | 3/4" | 2 | 2 | 110 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 110 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 110 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 110 cm
El16 | Segundo Pavimento | 2.5 | ø3/4" | 0.18 | 80 | 3/4" | 1 | 1 | 80 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 80 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 80 cm
El16 | Segundo Pavimento | 2.5 | ø3/4" | 0.18 | 50 | 3/4" | 1 | 1 | 50 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 100 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 50 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 50 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 50 cm
El17 | Segundo Pavimento | 2.5 | ø3/4" | 0.18 | 80 | 3/4" | 1 | 1 | 80 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 160 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 80 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 80 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 80 cm
El17 | Segundo Pavimento | 2.5 | ø3/4" | 0.18 | 40 | 3/4" | 1 | 1 | 40 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 80 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 40 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 40 cm
El18 | Segundo Pavimento | 2.5 | ø3/4" | 0.18 | 70 | 3/4" | 1 | 1 | 70 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 70 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 70 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 70 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 70 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 70 cm
El18 | Segundo Pavimento | 2.5 | ø3/4" | 0.18 | 20 | 3/4" | 1 | 1 | 20 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 40 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 20 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 20 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 20 cm
El18 | Segundo Pavimento | 2.5 | ø3/4" | 0.18 | 40 | 3/4" | 1 | 1 | 40 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 80 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 40 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 40 cm
El19 | Segundo Pavimento | 2.5 | ø3/4" | 0.18 | 210 | 3/4" | 3 | 3 | 210 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 210 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 210 cm
El20 | Segundo Pavimento | 2.5 | ø3/4" | 0.18 | 140 | 3/4" | 2 | 2 | 140 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 140 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 140 cm
El21 | Segundo Pavimento | 2.5 | ø3/4" | 0.18 | 130 | 3/4" | 2 | 2 | 130 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 130 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Branco: 130 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Azul claro: 130 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Branco: 130 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 2.5 mm² - Verde-amarelo: 130 cm
El3 | Segundo Pavimento | 2.5 | ø3/4" | 0.18 | 40 | 3/4" | 1 | 1 | 40 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 80 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 40 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 40 cm

# IfcFlowSegment: Eletroduto tipo pesado (PEAD) (118)
In: Nível 1
Type - PredefinedType: CONDUITSEGMENT
AltoQi_Builder - Comprimento máximo: 100 cm
Identificação_Elemento - Classe: Eletroduto PVC flexível; Tipo: Eletroduto tipo pesado (PEAD); Rede: Elétrica; Aplicação: Circular
Pset_CableCarrierSegmentTypeCommon - Reference: Eletroduto tipo pesado (PEAD)
Pset_CableCarrierSegmentTypeCableLadderSegment - NominalLength: 100 cm
Name | Diâmetro interno (cm) | Diâmetro | Espessura (cm) | Indicação | Comprimento (cm) | Nome | Eletroduto PVC flexível - Eletroduto pesado - 2" (cm) | Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Amarelo (cm) | Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Azul claro (cm) | Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 4 mm² - Amarelo (cm) | Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 4 mm² - Azul claro (cm) | Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 4 mm² - Verde-amarelo (cm)
El1 | 5 | ø2" | 0.63 | ø2" | 116 | 2" | 116 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 16 mm² - Azul claro: 116 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 16 mm² - Branco: 116 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 16 mm² - Preto: 116 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 16 mm² - Vermelho: 116 cm
El10 | 5 | ø2" | 0.63 | ø2" | 1120 | 2" | 1120 | 2240 | 2240 | 1120 | 1120 | 1120
El10 | 5 | ø2" | 0.63 | ø2" | 160 | 2" | 160 | 320 | 320 | 160 | 160 | 160
El100 | 3 | ø1 1/4" | 0.49 | ø1.1/4" | 260 | 1.1/4" |  |  |  | 260 | 260 | 260 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 260 cm
El101 | 3 | ø1 1/4" | 0.49 | ø1.1/4" | 360 | 1.1/4" |  |  |  | 360 | 360 | 360 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 360 cm
El102 | 3 | ø1 1/4" | 0.49 | ø1.1/4" | 110 | 1.1/4" |  |  |  | 110 | 110 | 110 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 110 cm
El103 | 3 | ø1 1/4" | 0.49 | ø1.1/4" | 160 | 1.1/4" |  |  |  | 160 | 160 | 160 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 160 cm
El104 | 3 | ø1 1/4" | 0.49 | ø1.1/4" | 130 | 1.1/4" |  |  |  | 130 | 130 | 130 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 130 cm
El105 | 3 | ø1 1/4" | 0.49 | ø1.1/4" | 325 | 1.1/4" |  |  |  | 325 | 325 | 325 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 325 cm
El106 | 3 | ø1 1/4" | 0.49 | ø1.1/4" | 120 | 1.1/4" |  |  |  | 120 | 120 | 120 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 120 cm
El107 | 3 | ø1 1/4" | 0.49 | ø1.1/4" | 260 | 1.1/4" |  |  |  | 260 | 260 | 260 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 260 cm
El108 | 3 | ø1 1/4" | 0.49 | ø1.1/4" | 110 | 1.1/4" |  |  |  | 110 | 110 | 110 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 110 cm
El11 | 5 | ø2" | 0.63 | ø2" | 30 | 2" | 30 | 30 | 30 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 30 cm
El110 | 5 | ø2" | 0.63 | ø2" | 190 | 2" | 190 | 190 | 190 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 190 cm
El111 | 5 | ø2" | 0.63 | ø2" | 170 | 2" | 170 | 170 | 170 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 170 cm
El112 | 5 | ø2" | 0.63 | ø2" | 245 | 2" | 245 | 245 | 245 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 245 cm
El113 | 5 | ø2" | 0.63 | ø2" | 360 | 2" | 360 | 360 | 360 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 360 cm
El12 | 5 | ø2" | 0.63 | ø2" | 720 | 2" | 720 | 1440 | 1440 | 720 | 720 | 720
El122 | 3 | ø1" | 0.49 | ø1" | 620 | 1'' |  | 620 | 620 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 620 cm; Eletroduto PVC flexível - Eletroduto pesado - 1": 620 cm
El13 | 5 | ø2" | 0.63 | ø2" | 10 | 2" | 10 | 10 | 10 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 10 cm
El131 | 5 | ø2" | 0.63 | ø2" | 1070 | 2" | 1070 | 1070 | 1070 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 1070 cm
El132 | 3 | ø1 1/4" | 0.49 | ø1.1/4" | 702.33 | 1.1/4" |  |  | 1404.66 |  | 1404.66 | 702.33 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 702.33 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Preto: 1404.66 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 4 mm² - Branco: 1404.66 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 4 mm² - Preto: 1404.66 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 4 mm² - Vermelho: 1404.66 cm
El133 | 3 | ø1 1/4" | 0.49 | ø1.1/4" | 580 | 1.1/4" |  |  | 580 |  | 580 | 580 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 580 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Preto: 580 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 4 mm² - Branco: 580 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 4 mm² - Preto: 580 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 4 mm² - Vermelho: 580 cm
El138 | 5 | ø2" | 0.63 | ø2" | 20 | 2" | 20 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 10 mm² - Azul claro: 20 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 10 mm² - Preto: 20 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 10 mm² - Verde-amarelo: 20 cm
El139 | 5 | ø2" | 0.63 | ø2" | 997.67 | 2" | 997.67 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 10 mm² - Azul claro: 997.67 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 10 mm² - Preto: 997.67 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 10 mm² - Verde-amarelo: 997.67 cm
El14 | 5 | ø2" | 0.63 | ø2" | 970 | 2" | 970 | 1940 | 1940 | 970 | 970 | 970
El140 | 5 | ø2" | 0.63 | ø2" | 1810 | 2" | 1810 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 10 mm² - Azul claro: 3620 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 10 mm² - Verde-amarelo: 3620 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 10 mm² - Branco: 1810 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 10 mm² - Vermelho: 1810 cm
El141 | 5 | ø2" | 0.63 | ø2" | 10 | 2" | 10
El142 | 5 | ø2" | 0.63 | ø2" | 1810 | 2" | 1810
El143 | 5 | ø2" | 0.63 | ø2" | 377.67 | 2" | 377.67 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 10 mm² - Azul claro: 377.67 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 10 mm² - Verde-amarelo: 377.67 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 10 mm² - Vermelho: 377.67 cm
El144 | 5 | ø2" | 0.63 | ø2" | 1507.67 | 2" | 1507.67 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 10 mm² - Azul claro: 1507.67 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 10 mm² - Verde-amarelo: 1507.67 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 10 mm² - Branco: 1507.67 cm
El15 | 5 | ø2" | 0.63 | ø2" | 10 | 2" | 10 | 10 | 10 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 10 cm
El155 | 5 | ø2" | 0.63 | ø2" | 1130 | 2" | 1130 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 1130 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 1130 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 1130 cm
El16 | 5 | ø2" | 0.63 | ø2" | 450 | 2" | 450 | 450 | 450 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 450 cm
El17 | 5 | ø2" | 0.63 | ø2" | 10 | 2" | 10
El174 | 5 | ø2" | 0.63 | ø2" | 1808 | 2" | 1808 | 1808 | 1808 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 1808 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 1808 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 1808 cm
El19 | 5 | ø2" | 0.63 | ø2" | 10 | 2" | 10 | 20 | 20 | 10 | 10 | 10
El2 | 5 | ø2" | 0.63 | ø2" | 918 | 2" | 918 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 16 mm² - Azul claro: 918 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 16 mm² - Branco: 918 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 16 mm² - Preto: 918 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 16 mm² - Vermelho: 918 cm
El20 | 5 | ø2" | 0.63 | ø2" | 490 | 2" | 490 | 980 | 980 | 490 | 490 | 490
El21 | 5 | ø2" | 0.63 | ø2" | 10 | 2" | 10 | 20 | 20 | 10 | 10 | 10
El22 | 5 | ø2" | 0.63 | ø2" | 810 | 2" | 810 | 1620 | 1620 | 810 | 810 | 810
El23 | 5 | ø2" | 0.63 | ø2" | 450.33 | 2" | 450.33 | 1350.99 | 1350.99 | 450.33 | 450.33 | 450.33 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 450.33 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 450.33 cm
El25 | 5 | ø2" | 0.63 | ø2" | 10 | 2" | 10 | 20 | 20 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 10 cm
El26 | 5 | ø2" | 0.63 | ø2" | 960 | 2" | 960 | 2880 | 2880 | 960 | 960 | 960 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 960 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 960 cm
El27 | 5 | ø2" | 0.63 | ø2" | 20 | 2" | 20 | 60 | 60 | 20 | 20 | 20 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 20 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 20 cm
El28 | 5 | ø2" | 0.63 | ø2" | 590 | 2" | 590 | 1770 | 1770 | 590 | 590 | 590 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 590 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 590 cm
El29 | 5 | ø2" | 0.63 | ø2" | 20 | 2" | 20 | 60 | 60 | 20 | 20 | 20 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 20 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 20 cm
El30 | 5 | ø2" | 0.63 | ø2" | 578 | 2" | 578 | 1156 | 1156 | 578 | 578 | 578
El31 | 5 | ø2" | 0.63 | ø2" | 20 | 2" | 20 | 40 | 40 | 20 | 20 | 20
El32 | 5 | ø2" | 0.63 | ø2" | 1033 | 2" | 1033 | 2066 | 2066 | 1033 | 1033 | 1033
El33 | 5 | ø2" | 0.63 | ø2" | 50 | 2" | 50 | 100 | 100 | 50 | 50 | 50
El34 | 5 | ø2" | 0.63 | ø2" | 1110 | 2" | 1110 | 2220 | 2220 | 1110 | 1110 | 1110
El35 | 5 | ø2" | 0.63 | ø2" | 60 | 2" | 60 | 120 | 120 | 60 | 60 | 60
El36 | 5 | ø2" | 0.63 | ø2" | 1580 | 2" | 1580 | 3160 | 3160 | 1580 | 1580 | 1580
El37 | 5 | ø2" | 0.63 | ø2" | 10 | 2" | 10 | 20 | 20 | 10 | 10 | 10
El38 | 5 | ø2" | 0.63 | ø2" | 1450 | 2" | 1450 | 1450 | 1450 | 1450 | 1450 | 1450
El39 | 5 | ø2" | 0.63 | ø2" | 10 | 2" | 10 | 10 | 10 | 10 | 10 | 10
El4 | 5 | ø2" | 0.63 | ø2" | 20 | 2" | 20 | 20 | 20 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 20 cm
El40 | 5 | ø2" | 0.63 | ø2" | 870 | 2" | 870 | 870 | 870 | 870 | 870 | 870
El41 | 5 | ø2" | 0.63 | ø2" | 20 | 2" | 20 | 20 | 20 | 20 | 20 | 20
El44 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 60 | 1.1/4" |  | 120 | 120 | 60 | 60 | 60 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 60 cm
El46 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 430 | 1.1/4" |  |  |  | 430 | 430 | 430 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 430 cm
El47 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 538 | 1.1/4" |  |  |  | 538 | 538 | 538 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 538 cm
El48 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 318 | 1.1/4" |  |  |  | 318 | 318 | 318 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 318 cm
El49 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 160 | 1.1/4" |  |  |  | 160 | 160 | 160 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 160 cm
El50 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 150 | 1.1/4" |  |  |  | 150 | 150 | 150 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 150 cm
El51 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 310 | 1.1/4" |  |  |  | 310 | 310 | 310 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 310 cm
El52 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 490 | 1.1/4" |  |  |  | 490 | 490 | 490 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 490 cm
El53 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 200 | 1.1/4" |  |  |  | 200 | 200 | 200 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 200 cm
El54 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 170 | 1.1/4" |  |  |  | 170 | 170 | 170 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 170 cm
El55 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 160 | 1.1/4" |  |  |  | 160 | 160 | 160 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 160 cm
El56 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 160 | 1.1/4" |  |  |  | 160 | 160 | 160 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 160 cm
El57 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 205 | 1.1/4" |  |  |  | 205 | 205 | 205 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 205 cm
2 x El58 | 5 | ø2" | 0.63 | ø2" | 270 | 2" | 270 | 270 | 270 | 270 | 270 | 270
El58 | 5 | ø2" | 0.63 | ø2" | 245 | 2" | 245 | 245 | 245 | 245 | 245 | 245
El59 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 50 | 1.1/4" |  | 50 | 50 | 50 | 50 | 50 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 50 cm
El6 | 5 | ø2" | 0.63 | ø2" | 10 | 2" | 10 | 20 | 20 | 10 | 10 | 10
El60 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 280 | 1.1/4" |  |  |  | 280 | 280 | 280 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 280 cm
El60 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 130 | 1.1/4" |  |  |  | 130 | 130 | 130 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 130 cm
El60 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 215 | 1.1/4" |  |  |  | 215 | 215 | 215 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 215 cm
El61 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 723 | 1.1/4" |  |  |  | 723 | 723 | 723 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 723 cm
El62 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 1095 | 1.1/4" |  |  |  | 1095 | 1095 | 1095 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 1095 cm
El63 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 210 | 1.1/4" |  |  |  | 210 | 210 | 210 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 210 cm
El65 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 1055 | 1.1/4" |  |  |  | 1055 | 1055 | 1055 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 1055 cm
El66 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 380 | 1.1/4" |  |  |  | 380 | 380 | 380 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 380 cm
El67 | 5 | ø2" | 0.63 | ø2" | 745 | 2" | 745 |  |  | 745 | 745 | 745
El68 | 5 | ø2" | 0.63 | ø2" | 818 | 2" | 818 | 1636 | 1636 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 818 cm
El69 | 5 | ø2" | 0.63 | ø2" | 20 | 2" | 20 | 40 | 40 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 20 cm
El70 | 5 | ø2" | 0.63 | ø2" | 450 | 2" | 450 | 900 | 900 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 450 cm
El71 | 5 | ø2" | 0.63 | ø2" | 880 | 2" | 880 | 880 | 880 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 880 cm
El72 | 5 | ø2" | 0.63 | ø2" | 60 | 2" | 60
El73 | 5 | ø2" | 0.63 | ø2" | 990 | 2" | 990 | 990 | 990 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 990 cm
El76 | 5 | ø2" | 0.63 | ø2" | 565 | 2" | 565 | 565 | 565 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 565 cm
El77 | 5 | ø2" | 0.63 | ø2" | 60 | 2" | 60 | 60 | 60 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 60 cm
El78 | 5 | ø2" | 0.63 | ø2" | 246 | 2" | 246 | 738 | 738 | 246 | 246 | 246 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 246 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 246 cm
El79 | 5 | ø2" | 0.63 | ø2" | 106 | 2" | 106 | 318 | 318 | 106 | 106 | 106 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 106 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 106 cm
El8 | 5 | ø2" | 0.63 | ø2" | 30 | 2" | 30 | 30 | 30 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo: 30 cm
El80 | 5 | ø2" | 0.63 | ø2" | 96 | 2" | 96 | 288 | 288 | 96 | 96 | 96 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 96 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 96 cm
El81 | 5 | ø2" | 0.63 | ø2" | 216 | 2" | 216 | 648 | 648 | 216 | 216 | 216 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 216 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 216 cm
El82 | 5 | ø2" | 0.63 | ø2" | 286 | 2" | 286 | 858 | 858 | 286 | 286 | 286 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 286 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 286 cm
El83 | 5 | ø2" | 0.63 | ø2" | 280 | 2" | 280 | 840 | 840 | 280 | 280 | 280 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 280 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 280 cm
El84 | 5 | ø2" | 0.63 | ø2" | 500 | 2" | 500 | 1500 | 1500 | 500 | 500 | 500 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 500 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 500 cm
El85 | 5 | ø2" | 0.63 | ø2" | 300 | 2" | 300 | 900 | 900 | 300 | 300 | 300 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 300 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 300 cm
El86 | 5 | ø2" | 0.63 | ø2" | 130 | 2" | 130 | 390 | 390 | 130 | 130 | 130 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 130 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 130 cm
El87 | 5 | ø2" | 0.63 | ø2" | 350 | 2" | 350 | 1050 | 1050 | 350 | 350 | 350 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 350 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 350 cm
El88 | 5 | ø2" | 0.63 | ø2" | 320 | 2" | 320 | 640 | 640 | 320 | 320 | 320
El89 | 5 | ø2" | 0.63 | ø2" | 210 | 2" | 210 | 420 | 420 | 210 | 210 | 210
El90 | 5 | ø2" | 0.63 | ø2" | 250 | 2" | 250 | 500 | 500 | 250 | 250 | 250
