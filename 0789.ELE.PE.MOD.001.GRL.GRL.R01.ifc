Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcFlowSegment: Eletroduto tipo pesado (PEAD) (118)
Name | Diâmetro interno (cm) | Diâmetro | Espessura (cm) | Indicação | Comprimento (cm) | Nome | Eletroduto PVC flexível - Eletroduto pesado - 2" (cm) | Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Amarelo (cm) | Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Azul claro (cm) | Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 4 mm² - Amarelo (cm) | Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 4 mm² - Azul claro (cm) | Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 4 mm² - Verde-amarelo (cm)
El91 | 5 | ø2" | 0.63 | ø2" | 250 | 2" | 250 | 500 | 500 | 250 | 250 | 250
El92 | 5 | ø2" | 0.63 | ø2" | 190 | 2" | 190 | 380 | 380 | 190 | 190 | 190
El93 | 5 | ø2" | 0.63 | ø2" | 300 | 2" | 300 | 600 | 600 | 300 | 300 | 300
El94 | 5 | ø2" | 0.63 | ø2" | 460 | 2" | 460 | 920 | 920 | 460 | 460 | 460
El95 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 200 | 1.1/4" |  |  |  | 200 | 200 | 200 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 200 cm
El96 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 270 | 1.1/4" |  |  |  | 270 | 270 | 270 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 270 cm
El97 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 160 | 1.1/4" |  |  |  | 160 | 160 | 160 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 160 cm
El98 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 60 | 1.1/4" |  |  |  | 60 | 60 | 60 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 60 cm
El99 | 3 | ø1 1/4" | 0.49 | ø1.1/4 | 180 | 1.1/4" |  |  |  | 180 | 180 | 180 | AltoQi_QiBuilder-Itens_Associados - Eletroduto PVC flexível - Eletroduto pesado - 1.1/4": 180 cm

# IfcFlowSegment: Eletroduto tipo reforçado (9)
In: Nível 1
Type - PredefinedType: CONDUITSEGMENT
AltoQi_Builder - Comprimento máximo: 100 cm
Identificação_Elemento - Classe: Eletroduto PVC flexível; Tipo: Eletroduto tipo reforçado; Rede: Elétrica; Aplicação: Circular
Pset_CableCarrierSegmentTypeCommon - Reference: Eletroduto tipo reforçado
Pset_CableCarrierSegmentTypeCableLadderSegment - NominalLength: 100 cm
Name | Diâmetro interno (cm) | Diâmetro | Espessura (cm) | Indicação | Comprimento (cm) | Nome | Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Amarelo (cm) = Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Azul claro (cm) = Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 2.5 mm² - Verde-amarelo (cm) | Eletroduto PVC flexível - Eletroduto leve - 1" (cm)
El114 | 2.56 | ø1" | 0.32 | ø1" | 180 | 1" | 180 | 180
El115 | 2.56 | ø1" | 0.32 | ø1" | 140 | 1" | 140 | 140
El116 | 2.56 | ø1" | 0.32 | ø1" | 90 | 1" | 90 | 90
El117 | 2.56 | ø1" | 0.32 | ø1" | 70 | 1" | 70 | 70
El126 | 2.56 | ø1" | 0.32 | ø1" | 478 | 1" | 478 | 478
El127 | 2.56 | ø1" | 0.32 | ø1" | 938 | 1" | 938 | 938
El130 | 2.56 | ø1" | 0.32 | ø1" | 120 | 1" | 120 | 120
El145 | 2.56 | ø1" | 0.32 | ø1" | 280 | 1" |  | 280 | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Amarelo: 280 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Azul claro: 280 cm; Cabo Unipolar - cobre - Isol.PVC - 450/750V - ref. Pirastic Ecoplus BWF Flexível - 1.5 mm² - Verde-amarelo: 280 cm
El3 | 4 | ø1 1/2" | 0.65 | ø1.1/2" | 102.33 | 1.1/2" | AltoQi_QiBuilder-Itens_Associados - Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 16 mm² - Verde-amarelo: 102.33 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 35 mm² - Azul claro: 102.33 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 35 mm² - Branco: 102.33 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 35 mm² - Preto: 102.33 cm; Cabo Unipolar - cobre - Isol. EPR - 0,6/1kV - ref. Inbrac Eprovinil - 35 mm² - Vermelho: 102.33 cm; Eletroduto PVC flexível - Eletroduto leve - 1/2": 102.33 cm

# IfcFlowTerminal: Ponto de luz (75)
Type - PredefinedType: DIRECTIONSOURCE
AltoQi_Builder - Requer aterramento: Sim
AltoQi_Builder-Ponto1 - Fator de potência (%): 100; Fluxo luminoso para tensão 12V: 0 lm; Quantidade: 1; Rendimento (%): 100; Tipo de luminária: A1 (Direta); Tipo de ponto: Lâmpada
Identificação_Elemento - Aplicação: Caixa; Classe: Biblioteca BIM - Elétrica; Tipo: Ponto de luz; Rede: Elétrica
Circuito - Pavimento_do_circuito_1: Nível 1; Quadro_1: QD-PRAÇA
Pset_LightFixtureTypeCommon - Reference: Ponto de luz
Pset_ElectricalDeviceCommon - HasProtectiveEarth: Sim
Name | In | Comprimento (cm) | Largura (cm) | Profundidade (cm) | Posição | Fluxo luminoso para tensão 127V (lm) | Fluxo luminoso para tensão 220V (lm) | Número de lâmpadas = NumberOfSource | Potência (W) | Descrição | Nome | Circuito_1 | Comando_1 | Acessórios p/ eletrodutos - Caixa PVC octogonal - 4"x 4"
7 x  | Nível 1 | 15 | 15 | 11 | Piso | 3000 | 3000 | 2 | 80 | Poste circulação- 2 pétalas | Poste circulação - 2 pétalas (R00) | 2 - Iluminação Postes | l | AltoQi_QiBuilder-Itens_Associados - Aterramento - Caixa de inspeção - PVC- Ø300x300mm: 1; Aterramento - Haste de aterramento - cobreada - 5/8" x 3,00m: 1; Poste de Iluminação - Poste de iluminação - Poste de iluminação - 2 pétalas, aço galvanizado a fogo, 6 metros com luminárias LED 200W: 1
19 x  | Nível 1 | 1 | 1 | 1 | Piso | 1980 | 1820 | 1 | 100 | Ponto genérico de luz 100W | Refletor 100W | 1 - Iluminação Refletores | k | 1
21 x  | Nível 1 | 7 | 4.75 | 10.85 | Alta | 1980 | 1820 | 1 | 100 | Ponto genérico de luz 100W | 100 W (parede) | 3 - Iluminação bancos | m | 1
8 x  | Nível 1 | 7 | 4.75 | 10.85 | Alta | 1980 | 1820 | 1 | 100 | Ponto de luz 15W | 15 W (parede) - condulete | 4 - Iluminação decorativa quiosques | n | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Condulete PVC 5 entradas - 1": 1
 | Nível 1 | 7 | 4.75 | 10.85 | Alta | 1980 | 1820 | 1 | 15 | Ponto genérico de luz 15W | 15 W (parede) - condulete 3/4 (R00) | 4 - Iluminação decorativa quiosques | n | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Condulete PVC 5 entradas - 3/4": 1
10 x  | Nível 1 | 7 | 4.75 | 10.85 | Alta | 1980 | 1820 | 1 | 100 | Ponto de luz 15W | 15 W (parede) - condulete | 11 - Iluminação Rua coberta | s | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Condulete PVC 5 entradas - 1": 1
 | Nível 1 | 7 | 4.75 | 10.85 | Alta | 1980 | 1820 | 1 | 100 | Ponto de luz 15W | 100 W (parede) - condulete | 11 - Iluminação Rua coberta | s | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Condulete PVC 5 entradas - 1": 1
 | Segundo Pavimento | 10.56 | 10.56 | 6.05 | Teto | 1980 | 1820 | 1 | 60 | Ponto genérico de luz 100W | 100 W condulete | 9 - Iluminação Banheiros | r | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Abraçadeira tipo unha - 1": 1; Acessórios p/ eletrodutos - Condulete PVC 6 entradas - 1": 1
 | Segundo Pavimento | 10.56 | 10.56 | 6.05 | Teto | 1980 | 1820 | 1 | 60 | Ponto genérico de luz 100W | 100 W condulete | 9 - Iluminação Banheiros | q | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Abraçadeira tipo unha - 1": 1; Acessórios p/ eletrodutos - Condulete PVC 6 entradas - 1": 1
3 x  | Segundo Pavimento | 10.56 | 10.56 | 6.05 | Teto | 1980 | 1820 | 1 | 60 | Ponto genérico de luz 100W | 100 W condulete | 9 - Iluminação Banheiros | o | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Abraçadeira tipo unha - 1": 1; Acessórios p/ eletrodutos - Condulete PVC 6 entradas - 1": 1
3 x  | Segundo Pavimento | 10.56 | 10.56 | 6.05 | Teto | 1980 | 1820 | 1 | 60 | Ponto genérico de luz 100W | 100 W condulete | 9 - Iluminação Banheiros | p | AltoQi_QiBuilder-Itens_Associados - Acessórios p/ eletrodutos - Abraçadeira tipo unha - 1": 1; Acessórios p/ eletrodutos - Condulete PVC 6 entradas - 1": 1
